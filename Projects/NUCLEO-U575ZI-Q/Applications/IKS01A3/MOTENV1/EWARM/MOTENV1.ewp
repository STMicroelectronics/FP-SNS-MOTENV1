# IAR project MOTENV1.ewp, settings and files
configuration MOTENV1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U575xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/ST/STM32_MotionID_Library/Inc; ../../../../../../Middlewares/ST/STM32_MotionGR_Library/Inc; ../../../../../../Drivers/BSP/Components/lsm6dso; ../../../../../../Drivers/BSP/Components/lis2dw12; ../../../../../../Drivers/BSP/Components/lis2mdl; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hh; ../../../../../../Drivers/BSP/Components/stts751; ../../../../../../Drivers/BSP/IKS01A3; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Middlewares/ST/STM32_MotionCP_Library/Inc; ../../../../../../Middlewares/ST/STM32_MotionFX_Library/Inc; ../../../../../../Middlewares/ST/STM32_MotionPM_Library/Inc; ../../../../../../Middlewares/ST/STM32_MotionAR_Library/Inc; ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic; ../../../../../../Middlewares/ST/BlueNRG-2/utils; ../../../../../../Middlewares/ST/BlueNRG-2/includes; ../../../../../../Middlewares/Third_Party/parson; ../../../../../../Middlewares/ST/STM32_BLE_Manager/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MOTENV1.bin
  ILINK.IlinkOutputFile: MOTENV1.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User
    ../Src/: app_motenv1.c ble_function.c BLE_Implementation.c hci_tl_interface.c hw_advance_features.c main.c motion_ar_manager.c motion_cp_manager.c motion_fx_manager.c motion_gr_manager.c motion_id_manager.c motion_pm_manager.c ota.c stm32u5xx_hal_msp.c stm32u5xx_it.c stm32u5xx_nucleo.c stm32u5xx_nucleo_bus.c target_platform.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/IKS01A3
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_ll_usb.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/parson/Data Exchange/parson
    ../../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/AccEvent
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_AccEvent.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Environmental
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Environmental.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Inertial
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Inertial.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Led
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Led.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/ActivityRecognition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_ActivityRecognition.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/CarryPosition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_CarryPosition.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/ECompass
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_ECompass.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/GestureRecognition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_GestureRecognition.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/MotionIntensity
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_MotionIntensity.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/PedometerAlgorithm
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_PedometerAlgorithm.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/SensorFusion
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_SensorFusion.c
  group Middlewares/STM32_BLE_Manager/BLE_Manager/BLE_Manager
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Manager.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionAR_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR_CM33F_wc32_ot_hard.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionCP_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionCP_Library/Lib/: MotionCP_CM33F_wc32_ot_hard.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionFX_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM33F_wc32_ot_hard.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionGR_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionGR_Library/Lib/: MotionGR_CM33F_wc32_ot_hard.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionID_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM33F_wc32_ot_hard.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionPM_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM33F_wc32_ot_hard.a
