# Keil uVision project MOTENV1.uvprojx, settings and files
target MOTENV1 (6180000::V6.18::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x80FDFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: MOTENV1 +hex
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c misc: -Wno-format
  c include: ../Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/ST/STM32_MotionID_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionGR_Library/Inc;../../../../../../Drivers/BSP/Components/lsm6dsv16x;../../../../../../Drivers/BSP/Components/lis2duxs12;../../../../../../Drivers/BSP/Components/lis2mdl;../../../../../../Drivers/BSP/Components/lsm6dso16is;../../../../../../Drivers/BSP/Components/sht40ad1b;../../../../../../Drivers/BSP/Components/lps22df;../../../../../../Drivers/BSP/Components/stts22h;../../../../../../Drivers/BSP/IKS4A1;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_MotionCP_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionFX_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionPM_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionAR_Library/Inc;../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic;../../../../../../Middlewares/ST/BlueNRG-2/utils;../../../../../../Middlewares/ST/BlueNRG-2/includes;../../../../../../Middlewares/Third_Party/parson;../../../../../../Middlewares/ST/STM32_BLE_Manager/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xfe000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  scatter file: stm32u575zxx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User
    ../Src/: main.c motion_ar_manager.c motion_cp_manager.c motion_fx_manager.c motion_gr_manager.c motion_id_manager.c motion_pm_manager.c target_platform.c hw_advance_features.c ble_function.c ota.c app_motenv1.c hci_tl_interface.c BLE_Implementation.c stm32u5xx_nucleo_bus.c stm32u5xx_nucleo.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dsv16x/: lsm6dsv16x_reg.c lsm6dsv16x.c
    ../../../../../../Drivers/BSP/Components/lis2duxs12/: lis2duxs12_reg.c lis2duxs12.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c lis2mdl.c
    ../../../../../../Drivers/BSP/Components/lsm6dso16is/: lsm6dso16is_reg.c lsm6dso16is.c
    ../../../../../../Drivers/BSP/Components/sht40ad1b/: sht40ad1b_reg.c sht40ad1b.c
    ../../../../../../Drivers/BSP/Components/lps22df/: lps22df_reg.c lps22df.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c stts22h.c
  group Drivers/BSP/IKS4A1
    ../../../../../../Drivers/BSP/IKS4A1/: iks4a1_motion_sensors.c iks4a1_motion_sensors_ex.c iks4a1_env_sensors.c iks4a1_env_sensors_ex.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionID_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM33F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionGR_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionGR_Library/Lib/: MotionGR_CM33F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionCP_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionCP_Library/Lib/: MotionCP_CM33F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionFX_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM33F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionPM_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM33F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionAR_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR_CM33F_wc16_ot.a
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/parson/Data Exchange/parson
    ../../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/AccEvent
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_AccEvent.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Led
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Led.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Environmental
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Environmental.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Inertial
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Inertial.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/CarryPosition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_CarryPosition.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/ECompass
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_ECompass.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/GestureRecognition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_GestureRecognition.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/PedometerAlgorithm
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_PedometerAlgorithm.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/SensorFusion
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_SensorFusion.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/ActivityRecognition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_ActivityRecognition.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/MotionIntensity
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_MotionIntensity.c
  group Middlewares/STM32_BLE_Manager/BLE_Manager/BLE_Manager
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Manager.c
software components: CMSIS:CORE 4.3.0
