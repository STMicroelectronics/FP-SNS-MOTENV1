<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F401RE-Nucleo_IKS01A2_MOTENV1.ewp</path>
  </project>
  <batchBuild />
</workspace>
