# IAR project STM32F401RE-Nucleo_IKS01A3_MOTENV1.ewp, settings and files
configuration STM32F401RE-Nucleo_IKS01A3_MOTENV1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; STM32_NUCLEO
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic; ../../../../../../Middlewares/ST/BlueNRG-2/utils; ../../../../../../Middlewares/ST/BlueNRG-2/includes; ../../../../../../Drivers/BSP/Components/lsm6dso; ../../../../../../Drivers/BSP/Components/lis2dw12; ../../../../../../Drivers/BSP/Components/lis2mdl; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hh; ../../../../../../Drivers/BSP/Components/stts751; ../../../../../../Drivers/BSP/IKS01A3; ../../../../../../Drivers/BSP/Components/Common; ..\..\..\..\..\..\Middlewares\ST\STM32_BLE_Manager\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionAR_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionCP_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionGR_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\parson
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F401RE-Nucleo_IKS01A3_MOTENV1.bin
  ILINK.IlinkOutputFile: STM32F401RE-Nucleo_IKS01A3_MOTENV1.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: BLE_Implementation.c hci_tl_interface.c HWAdvanceFeatures.c main.c MotionAR_Manager.c MotionCP_Manager.c MotionFX_Manager.c MotionGR_Manager.c MotionID_Manager.c MotionPM_Manager.c OTA.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_nucleo.c stm32f4xx_nucleo_bus.c TargetPlatform.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/IKS01A3
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/BLE_Manager
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_AccEvent.c BLE_ActivityRecognition.c BLE_CarryPosition.c BLE_ECompass.c BLE_Environmental.c BLE_GestureRecognition.c BLE_Inertial.c BLE_Led.c BLE_Manager.c BLE_MotionIntensity.c BLE_PedometerAlgorithm.c BLE_SensorFusion.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/json
    ../../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/STM32_MotionAR
    ../../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionCP
    ../../../../../../Middlewares/ST/STM32_MotionCP_Library/Lib/: MotionCP_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionFX
    ../../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionGR
    ../../../../../../Middlewares/ST/STM32_MotionGR_Library/Lib/: MotionGR_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionID
    ../../../../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionPM
    ../../../../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc32_ot.a
