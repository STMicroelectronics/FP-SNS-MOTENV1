# IAR project MOTENV1.ewp, settings and files
configuration MOTENV1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic; ../../../../../../Middlewares/ST/BlueNRG-2/utils; ../../../../../../Middlewares/ST/BlueNRG-2/includes; ../../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../../Drivers/BSP/Components/lsm6dsl; ../../../../../../Drivers/BSP/Components/lsm303agr; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/IKS01A2; ../../../../../../Drivers/BSP/Components/Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MOTENV1.bin
  ILINK.IlinkOutputFile: MOTENV1.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: main.c TargetPlatform.c HWAdvanceFeatures.c BLE_Function.c app_motenv1.c hci_tl_interface.c BLE_Implementation.c stm32l0xx_nucleo_bus.c stm32l0xx_nucleo.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl_reg.c lsm6dsl.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr_reg.c lsm303agr.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221_reg.c hts221.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb_reg.c lps22hb.c
  group Drivers/BSP/IKS01A2
    ../../../../../../Drivers/BSP/IKS01A2/: iks01a2_motion_sensors.c iks01a2_motion_sensors_ex.c iks01a2_env_sensors.c iks01a2_env_sensors_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/AccEvent
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_AccEvent.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Environmental
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Environmental.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Inertial
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Inertial.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Led
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Led.c
  group Middlewares/STM32_BLE_Manager/BLE_Manager/BLE_Manager
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Manager.c
