# Keil uVision project MOTENV1.uvprojx, settings and files
target MOTENV1 (6190000::V6.19::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MOTENV1 +hex
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: -Wno-format
  c include: ../Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/Third_Party/parson;../../../../../../Middlewares/ST/STM32_BLE_Manager/Inc;../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic;../../../../../../Middlewares/ST/BlueNRG-2/utils;../../../../../../Middlewares/ST/BlueNRG-2/includes;../../../../../../Middlewares/ST/STM32_MotionID_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionGR_Library/Inc;../../../../../../Drivers/BSP/Components/lsm6dsv16x;../../../../../../Drivers/BSP/Components/lis2duxs12;../../../../../../Drivers/BSP/Components/lis2mdl;../../../../../../Drivers/BSP/Components/lsm6dso16is;../../../../../../Drivers/BSP/Components/sht40ad1b;../../../../../../Drivers/BSP/Components/lps22df;../../../../../../Drivers/BSP/Components/stts22h;../../../../../../Drivers/BSP/IKS4A1;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_MotionCP_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionFX_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionPM_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionAR_Library/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c motion_ar_manager.c motion_cp_manager.c motion_fx_manager.c motion_gr_manager.c motion_id_manager.c motion_pm_manager.c target_platform.c hw_advance_features.c ble_function.c ota.c app_motenv1.c hci_tl_interface.c ble_implementation.c stm32l4xx_nucleo_bus.c stm32l4xx_nucleo.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dsv16x/: lsm6dsv16x_reg.c lsm6dsv16x.c
    ../../../../../../Drivers/BSP/Components/lis2duxs12/: lis2duxs12_reg.c lis2duxs12.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c lis2mdl.c
    ../../../../../../Drivers/BSP/Components/lsm6dso16is/: lsm6dso16is_reg.c lsm6dso16is.c
    ../../../../../../Drivers/BSP/Components/sht40ad1b/: sht40ad1b_reg.c sht40ad1b.c
    ../../../../../../Drivers/BSP/Components/lps22df/: lps22df_reg.c lps22df.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c stts22h.c
  group Drivers/BSP/IKS4A1
    ../../../../../../Drivers/BSP/IKS4A1/: iks4a1_motion_sensors.c iks4a1_motion_sensors_ex.c iks4a1_env_sensors.c iks4a1_env_sensors_ex.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/parson/Data Exchange/parson
    ../../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/AccEvent
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_acc_event.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Led
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_led.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Environmental
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_environmental.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Inertial
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_inertial.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/CarryPosition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_carry_position.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/ECompass
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_e_compass.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/GestureRecognition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_gesture_recognition.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/PedometerAlgorithm
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_pedometer_algorithm.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/SensorFusion
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_sensor_fusion.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/ActivityRecognition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_activity_recognition.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/MotionIntensity
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_motion_intensity.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/BLE_Manager
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_manager.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionID_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionGR_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionGR_Library/Lib/: MotionGR_CM4F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionCP_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionCP_Library/Lib/: MotionCP_CM4F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionFX_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionPM_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionAR_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR_CM4F_wc16_ot.a
software components: CMSIS:CORE 5.6.0
