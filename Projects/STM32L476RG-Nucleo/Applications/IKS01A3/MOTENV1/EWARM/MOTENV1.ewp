# IAR project MOTENV1.ewp, settings and files
configuration MOTENV1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/ST/STM32_MetaDataManager; ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic; ../../../../../../Middlewares/ST/BlueNRG-2/utils; ../../../../../../Middlewares/ST/BlueNRG-2/includes; ../../../../../../Middlewares/Third_Party/parson; ../../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../../Middlewares/ST/STM32_MotionID_Library/Inc; ../../../../../../Middlewares/ST/STM32_MotionGR_Library/Inc; ../../../../../../Drivers/BSP/Components/lsm6dso; ../../../../../../Drivers/BSP/Components/lis2dw12; ../../../../../../Drivers/BSP/Components/lis2mdl; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hh; ../../../../../../Drivers/BSP/Components/stts751; ../../../../../../Drivers/BSP/IKS01A3; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Middlewares/ST/STM32_MotionCP_Library/Inc; ../../../../../../Middlewares/ST/STM32_MotionFX_Library/Inc; ../../../../../../Middlewares/ST/STM32_MotionPM_Library/Inc; ../../../../../../Middlewares/ST/STM32_MotionAR_Library/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MOTENV1.bin
  ILINK.IlinkOutputFile: MOTENV1.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c MotionAR_Manager.c MotionCP_Manager.c MotionFX_Manager.c MotionGR_Manager.c MotionID_Manager.c MotionPM_Manager.c TargetPlatform.c HWAdvanceFeatures.c BLE_Function.c OTA.c app_motenv1.c hci_tl_interface.c BLE_Implementation.c stm32l4xx_nucleo_bus.c stm32l4xx_nucleo.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso_reg.c lsm6dso.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12_reg.c lis2dw12.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c lis2mdl.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221_reg.c hts221.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.c lps22hh.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751_reg.c stts751.c
  group Drivers/BSP/IKS01A3
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c iks01a3_env_sensors.c iks01a3_env_sensors_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/parson/Data Exchange/parson
    ../../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/AccEvent
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_AccEvent.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Environmental
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Environmental.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Inertial
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Inertial.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Led
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Led.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/ActivityRecognition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_ActivityRecognition.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/CarryPosition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_CarryPosition.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/ECompass
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_ECompass.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/GestureRecognition
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_GestureRecognition.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/MotionIntensity
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_MotionIntensity.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/PedometerAlgorithm
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_PedometerAlgorithm.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/SoftwareLibraries/SensorFusion
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_SensorFusion.c
  group Middlewares/STM32_BLE_Manager/BLE_Manager/BLE_Manager
    ../../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Manager.c
  group Middlewares/STM32_MetaDataManager/Data Exchange/STM32_MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionAR_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR_CM4F_wc32_ot_hard.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionCP_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionCP_Library/Lib/: MotionCP_CM4F_wc32_ot_hard.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionFX_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc32_ot_hard.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionGR_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionGR_Library/Lib/: MotionGR_CM4F_wc32_ot_hard.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionID_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc32_ot_hard.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionPM_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc32_ot_hard.a
